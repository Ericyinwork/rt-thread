# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F407xx
  c include: applications;.;..\..\..\components\net\at\include;packages\bme280-latest;packages\bme280-latest\libraries;..\..\..\components\cplusplus;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\components\drivers\spi\sfud\inc;..\..\..\components\drivers\include;board;board\CubeMX_Config\Inc;board\ports;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\config;..\libraries\HAL_Drivers\drv_flash;packages\fal-v0.4.0\inc;..\..\..\components\finsh;.;..\..\..\include;..\..\..\components\libc\compilers\common;packages\ota_downloader-latest;..\..\..\components\drivers\usb\usbdevice;..\..\..\components\drivers\sensors;..\..\..\components\drivers\include;..\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;..\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;..\libraries\STM32F4xx_HAL\CMSIS\Include;packages\u8g2-cpp-latest;packages\u8g2-cpp-latest\port;..\..\..\components\utilities\ymodem
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.cpp oled_gui.cpp myfont.c sendwave.c cmd.c strref.c util.c cyclequeue.c ota.c
  group AT
    ../../../components/net/at/src/: at_utils.c at_cli.c at_client.c
  group bme280
    packages/bme280-latest/: sensor_bosch_bme280.c
    packages/bme280-latest/libraries/: bme280.c
  group CPlusPlus
    ../../../components/cplusplus/: cxx_Mutex.cpp cxx_Semaphore.cpp cxx_Thread.cpp cxx_crt.cpp crt_init.c
  group cpu
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../../components/drivers/misc/: pin.c adc.c rt_drv_pwm.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group Drivers
    board/: board.c
    board/ports/: spi_oled_init.c rscdrrm020ndse3.c Pressure_Comp.c crc.c bme280_port.c
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_pwm.c drv_spi.c drv_soft_i2c.c drv_adc.c drv_usbd.c drv_common.c
    ../libraries/HAL_Drivers/drv_flash/: drv_flash_f4.c
  group fal
    packages/fal-v0.4.0/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
  group finsh
    ../../../components/finsh/: shell.c cmd.c msh.c
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group libc
    ../../../components/libc/compilers/common/: time.c
  group ota_downloader
    packages/ota_downloader-latest/src/: ymodem_ota.c
  group rt_usbd
    ../../../components/drivers/usb/usbdevice/core/: usbdevice_core.c usbdevice.c
    ../../../components/drivers/usb/usbdevice/class/: cdc_vcom.c
  group Sensors
    ../../../components/drivers/sensors/: sensor.c sensor_cmd.c
  group STM32_HAL
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_qspi.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_hcd.c stm32f4xx_ll_usb.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_lptim.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c
  group U8G2
    packages/u8g2-cpp-latest/src/: u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_d_a2printer.c u8x8_d_il3820_296x128.c u8x8_d_ist3020.c u8x8_d_ks0108.c u8x8_d_lc7981.c u8x8_d_ld7032_60x32.c u8x8_d_ls013b7dh03.c u8x8_d_max7219.c u8x8_d_pcd8544_84x48.c u8x8_d_pcf8812.c u8x8_d_pcf8814_hx1230.c u8x8_d_sbn1661.c u8x8_d_sed1330.c u8x8_d_sh1106_64x32.c u8x8_d_sh1106_72x40.c u8x8_d_sh1107.c u8x8_d_sh1108.c u8x8_d_sh1122.c u8x8_d_ssd1305.c u8x8_d_ssd1306_128x32.c u8x8_d_ssd1306_128x64_noname.c u8x8_d_ssd1306_48x64.c u8x8_d_ssd1306_64x32.c u8x8_d_ssd1306_64x48.c u8x8_d_ssd1306_96x16.c u8x8_d_ssd1309.c u8x8_d_ssd1317.c u8x8_d_ssd1318.c u8x8_d_ssd1322.c u8x8_d_ssd1325.c u8x8_d_ssd1326.c u8x8_d_ssd1327.c u8x8_d_ssd1329.c u8x8_d_ssd1606_172x72.c u8x8_d_ssd1607_200x200.c u8x8_d_st75256.c u8x8_d_st7565.c u8x8_d_st7567.c u8x8_d_st7586s_erc240160.c u8x8_d_st7586s_s028hn118a.c u8x8_d_st7588.c u8x8_d_st7920.c u8x8_d_stdio.c u8x8_d_t6963.c u8x8_d_uc1601.c u8x8_d_uc1604.c u8x8_d_uc1608.c u8x8_d_uc1610.c u8x8_d_uc1611.c u8x8_d_uc1617.c u8x8_d_uc1638.c u8x8_d_uc1701_dogs102.c u8x8_d_uc1701_mini12864.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u16toa.c u8x8_u8toa.c
    packages/u8g2-cpp-latest/port/: Print.cpp u8g2_port.cpp
  group Utilities
    ../../../components/utilities/ymodem/: ymodem.c
